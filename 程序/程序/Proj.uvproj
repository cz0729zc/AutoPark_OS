# Keil uVision project Proj.uvproj, settings and files
target Proj (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\Core_M3;.\System;.\User\Device;.\User\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core_M3
    ./Core_M3/: core_cm3.c
  group System
    ./System/: system_stm32f10x.c startup_stm32f10x_md.s
  group User
    ./User/Device/: delay.c sys.c LCD1602.c timer.c RC522.c exti.c stmflash.c 24cxx.c myiic.c
    ./User/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_flash.c usart1.c
    ./: main.c
